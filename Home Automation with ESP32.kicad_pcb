# Repository shyam7070/30A-Home-Automation

## KiCad design Home Automation with ESP32.kicad_pcb

Parts:
C1: 10uF; C_0805_2012Metric
C2: 22uF; C_0805_2012Metric
D1, D4: LED; LED_0805_2012Metric
D2, D3: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
J1: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J2: Screw_Terminal_01x04; TerminalBlock_bornier-4_P5.08mm
J3: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
K1: RAYEX-L90AS; Relay_SPST_RAYEX-L90AS
K2: PR13-5V-450-1C; RELAY_PR13-5V-450-1C; PARTREV 1.0
PS1: HLK-PM01; Converter_ACDC_Hi-Link_HLK-PMxx
Q1, Q2: S8050; TO-92_Inline
R1, R2, R3, R4, R5, R6: 1K; R_0805_2012Metric
R7, R8: 10K; R_0805_2012Metric
SW1, SW2: SW_Push; SW_PUSH_6mm
U1: ESP32-WROOM-32
U2, U3: PC817; DIP-4_W7.62mm
U4: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
/3V3: C2.1, J1.4, R7.1, R8.1, U1.2 (VDD), U4.2 (VO)
/5V: C1.1, D2.1 (K), D3.1 (K), K1.A1, K2.A1, PS1.4 (+Vout), U4.3 (VI)
/BOOT: R7.2, SW1.1, U1.25 (IO0)
/EN: R8.2, SW2.1, U1.3 (EN)
/IN1: J3.1, U1.6 (IO34)
/IN2: J3.2, U1.7 (IO35)
/L1: J2.2, K1.13
/L2: J2.1, K2.NO
/LED1: R5.1, U1.14 (IO12)
/LED2: R6.1, U1.16 (IO13)
/P: K1.14, K2.COM
/R1: R1.2, U1.36 (IO22)
/R2: R2.2, U1.37 (IO23)
/RXD: J1.2, U1.34 (RXD0/IO3)
/TXD: J1.1, U1.35 (TXD0/IO1)
GND: C1.2, C2.2, D1.1 (K), D4.1 (K), J1.3, J3.3, PS1.3 (-Vout), Q1.1 (E), Q2.1 (E), SW1.2, SW2.2, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.2, U2.4, U3.2, U3.4, U4.1 (GND)
unnamed: D1.2 (A), R5.2
unnamed: D2.2 (A), K1.A2, Q1.3 (C)
unnamed: D3.2 (A), K2.A2, Q2.3 (C)
unnamed: D4.2 (A), R6.2
unnamed: J2.3, PS1.2 (AC/N)
unnamed: J2.4, PS1.1 (AC/L)
unnamed: Q1.2 (B), R3.1
unnamed: Q2.2 (B), R4.1
unnamed: R1.1, U2.1
unnamed: R2.1, U3.1
unnamed: R3.2, U2.3
unnamed: R4.2, U3.3

Notes on the sheet:
RESET & BOOT
SWITCHES
LED'S
RELAYS
POWER SUPPLY
UART
MCU

Board: 2 copper layers, 80.1 x 68.5 mm, 28 parts (0 on the bottom side), 28 nets.
